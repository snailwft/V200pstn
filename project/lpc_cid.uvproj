# Keil uVision project lpc_cid.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1113FHN33/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x6000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(50000000) ELITTLE
  output: lpc_cid
  c flags: Optim=1 wLevel=2
  c include: ..\Drive;..\System;..\User
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../Startup/: startup_LPC11xx.s
  group System
    ../System/: system_LPC11xx.c
  group Drive
    ../Drive/: com.c ct.c dtmf.c fsk.c gpio.c pstn.c uart.c wdt.c
  group User
    ../User/: main.c
