# Keil uVision project lpc_project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(50000000) ELITTLE
  output: lpc_project +hex
  c flags: Optim=3 oTime=1
  c include: .\User;.\Drive;.\System
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC11xx.s
  group System
    ./System/: system_LPC11xx.c
  group User
    ./User/: main.c
  group Drive
    ./Drive/: ct.c gpio.c uart.c fsk.c com.c
